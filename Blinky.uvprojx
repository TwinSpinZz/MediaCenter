# Keil uVision project Blinky.uvprojx, settings and files
target LPC1768 Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --diag_suppress 550
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s
  group System Code
    ./: system_LPC17xx.c
  group Core Code
    ./: core_cm3.c
  group Source Code
    ./: Blinky.c IRQ.c GLCD_SPI_LPC1700.c LED.c photo.c KBD.c KBD.h usbuser.c usbhw.c usbdesc.c usbcore.c usbdmain.c adcuser.c CNTower.c ace_of_spades.c eight_of_spades.c five_of_hearts.c four_of_hearts.c jack_of_hearts.c king_of_clubs.c nine_of_hearts.c queen_of_diamonds.c seven_of_clubs.c six_of_diamonds.c ten_of_spades.c three_of_spades.c two_of_diamonds.c backCard.c redBackCard.c memory.c snake.c cloy.c ENGBuilding.c LoL.c natsu.c
  group Pictures
    ./: Bg_16bpp_t.c Bg_16bpp_l.c Bg_16bpp_r.c Bg_16bpp_b.c ARM_Ani_16bpp.c
  group Documentation
    ./: Abstract.txt
